/* GENERATED CODE -- CHANGES WILL BE OVERWRITTEN */

define symbol CYDEV_BTLDR_SIZE = 0x00000B00;
