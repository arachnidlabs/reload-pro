# Keil uVision project Reload Pro_PSoC4lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C4245PVI-482 Cypress
  cpu: "IRAM(0x20000000-0x20000FFF)IROM(0x0-0x7FFF)CLOCK(48000000)CPUTYPE( "Cortex-M0") ESEL ELITTLE"
  output: Reload Pro_PSoC4lib (library)
  group Source Files
    ./Generated_Source/PSoC4/: cyfitter_cfg.h cyfitter_cfg.c cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h IDAC_1.c IDAC_1.h IDAC_1_PM.c AMux_1.c AMux_1.h idac_hi.c idac_hi.h idac_hi_aliases.h idac_low.c idac_low.h idac_low_aliases.h opamp_pos_hi.c opamp_pos_hi.h opamp_pos_hi_aliases.h opamp_pos_low.c opamp_pos_low.h opamp_pos_low_aliases.h AMux_2.c AMux_2.h Opamp_1.c Opamp_1.h Opamp_1_PM.c opamp_out.c opamp_out.h opamp_out_aliases.h opamp_neg.c opamp_neg.h opamp_neg_aliases.h voltage_sense.c voltage_sense.h voltage_sense_aliases.h current_sense.c current_sense.h current_sense_aliases.h DieTemp_1.h DieTemp_1.c disp_ss.c disp_ss.h disp_ss_aliases.h disp_mosi.c disp_mosi.h disp_mosi_aliases.h disp_sclk.c disp_sclk.h disp_sclk_aliases.h SPIM_1.c SPIM_1.h SPIM_1_PM.c SPIM_1_INT.c SPIM_1_PVT.h PrISM_1.c PrISM_1.h PrISM_1_PM.c Clock_1.c Clock_1.h backlight.c backlight.h backlight_aliases.h QuadDec_1.c QuadDec_1.h QuadDec_1_PM.c quad_a.c quad_a.h quad_a_aliases.h quad_b.c quad_b.h quad_b_aliases.h Clock_2.c Clock_2.h quad_button.c quad_button.h quad_button_aliases.h SPIM_1_IntClock.c SPIM_1_IntClock.h cm0gcc.ld Cm0RealView.scat core_cm0_psoc4.h core_cm0.c core_cm0.h CyBootAsmGnu.s CyFlash.c CyFlash.h CyLib.c CyLib.h cyPm.c cyPm.h cytypes.h cyutils.c cypins.h project.h gate_sense_hi.c gate_sense_hi.h gate_sense_hi_aliases.h gate_sense_lo.c gate_sense_lo.h gate_sense_lo_aliases.h UART_1.c UART_1.h UART_1_SPI_UART.h UART_1_SPI_UART.c UART_1_SPI_UART_INT.c UART_1_PM.c UART_1_UART.c UART_1_BOOT.c UART_1_UART_BOOT.c UART_1_PINS.h UART_1_SPI_UART_PVT.h UART_1_PVT.h UART_1_rx.c UART_1_rx.h UART_1_rx_aliases.h UART_1_SCBCLK.c UART_1_SCBCLK.h UART_1_tx.c UART_1_tx.h UART_1_tx_aliases.h ADC_SAR_Seq_1.c ADC_SAR_Seq_1.h ADC_SAR_Seq_1_PM.c ADC_SAR_Seq_1_INT.c ADC_SAR_Seq_1_intClock.c ADC_SAR_Seq_1_intClock.h ADC_SAR_Seq_1_IRQ.c ADC_SAR_Seq_1_IRQ.h disp_reset.c disp_reset.h disp_reset_aliases.h
target Release (ARM-GNU)
  device: CY8C4245PVI-482 Cypress
  cpu: as above
  output: Reload Pro_PSoC4lib (library)
